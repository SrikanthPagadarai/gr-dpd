<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>hier_estimate_integer_delay</value></param>
<param><key>category</key><value>[dpd]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Estimate Integer Delay</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>NFFT</value></param>
<param><key>label</key><value>FFT Size</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>STS_len</value></param>
<param><key>label</key><value>STS Length</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>STS_signed_ampl_diff</value></param>
<param><key>label</key><value>Reference</value></param>
<param><key>value</key><value>[-1,-1,-1,-1,1,1,1,1,1,-1]</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>corr_len</value></param>
<param><key>label</key><value>Correlation Length</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>digital_predistortion_peak_detect</key>
<param><key>id</key><value>digital_predistortion_peak_detect_0</value></param>
<param><key>NFFT</key><value>NFFT</value></param>
<param><key>ovx</key><value>ovx</value></param>
<param><key>peak_cond</key><value>peak_val</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>STS_signed_ampl_diff[0:corr_len+1]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>hier_ampl_diff</key>
<param><key>id</key><value>hier_ampl_diff_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ovx</value></param>
<param><key>label</key><value>Oversampling Factor</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>peak_val</value></param>
<param><key>label</key><value>Correlation Peak Value</value></param>
<param><key>value</key><value>0</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>digital_predistortion_peak_detect_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_predistortion_peak_detect_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_ampl_diff_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>digital_predistortion_peak_detect_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>hier_ampl_diff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
