<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>hier_basic_ieee80222_tx_withoutCP</value></param>
<param><key>category</key><value>ieee_80222_tx</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Basic Tx without CP</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N</value></param>
<param><key>label</key><value># of Symbols</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>NFFT</value></param>
<param><key>label</key><value>FFT Size</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max</key><value>4</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>used_sc*N</value></param>
<param><key>type</key><value>int</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0_0</value></param>
<param><key>max</key><value>64</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>used_sc*N</value></param>
<param><key>type</key><value>int</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>in_type</key><value>int</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>(1+1j, 1-1j, -1-1j, -1+1j)</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>int</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>(-7+7j,-7+5j,-7+1j,-7+3j,-7-7j,-7-5j,-7-1j,-7-3j,-5+7j,-5+5j,-5+1j,-5+3j,-5-7j,-5-5j,-5-1j,-5-3j,-1+7j,-1+5j,-1+1j,-1+3j,-1-7j,-1-5j,-1-1j,-1-3j,-3+7j,-3+5j,-3+1j,-3+3j,-3-7j,-3-5j,-3-1j,-3-3j,7+7j,7+5j,7+1j,7+3j,7-7j,7-5j,7-1j,7-3j,5+7j,5+5j,5+1j,5+3j,5-7j,5-5j,5-1j,5-3j,1+7j,1+5j,1+1j,1+3j,1-7j,1-5j,1-1j,1-3j,3+7j,3+5j,3+1j,3+3j,3-7j,3-5j,3-1j,3-3j)</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>NFFT*ovx</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>False</value></param>
<param><key>window</key><value>window.rectangular(NFFT*ovx)</value></param>
</block>
<block>
<key>ieee_80222_tx_stream_to_zero_padded_vector</key>
<param><key>id</key><value>ieee_80222_tx_stream_to_zero_padded_vector_0</value></param>
<param><key>NFFT</key><value>NFFT</value></param>
<param><key>ovx</key><value>ovx</value></param>
<param><key>used_sc</key><value>used_sc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ovx</value></param>
<param><key>label</key><value>Oversampling Factor</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
<param><key>vlen</key><value>NFFT*ovx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>used_sc</value></param>
<param><key>label</key><value>Used Subcarriers</value></param>
<param><key>value</key><value>1680</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>ieee_80222_tx_stream_to_zero_padded_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0</source_block_id><sink_block_id>ieee_80222_tx_stream_to_zero_padded_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee_80222_tx_stream_to_zero_padded_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
