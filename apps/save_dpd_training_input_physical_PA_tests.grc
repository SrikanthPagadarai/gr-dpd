<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>DPDParams</value></param>
<param><key>field0</key><value>Ka</value></param>
<param><key>field1</key><value>La</value></param>
<param><key>field2</key><value>Kb</value></param>
<param><key>field3</key><value>Mb</value></param>
<param><key>field4</key><value>Lb</value></param>
<param><key>value0</key><value>5</value></param>
<param><key>value2</key><value>5</value></param>
<param><key>value1</key><value>3</value></param>
<param><key>value4</key><value>3</value></param>
<param><key>value3</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>DPDParams.Ka*DPDParams.La+DPDParams.Kb*DPDParams.Mb*DPDParams.Lb</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>TxParams</value></param>
<param><key>value7</key><value>30</value></param>
<param><key>value2</key><value>512</value></param>
<param><key>value6</key><value>0.5e9</value></param>
<param><key>field0</key><value>NFFT</value></param>
<param><key>field1</key><value>UsedSC</value></param>
<param><key>field2</key><value>CPlen</value></param>
<param><key>field3</key><value>Ovx</value></param>
<param><key>field4</key><value>SampRate</value></param>
<param><key>field5</key><value>N</value></param>
<param><key>field6</key><value>CenterFreq</value></param>
<param><key>field7</key><value>BBampl</value></param>
<param><key>value5</key><value>10000</value></param>
<param><key>value0</key><value>2048</value></param>
<param><key>value3</key><value>6</value></param>
<param><key>value4</key><value>100e6/256.0</value></param>
<param><key>value1</key><value>1680</value></param>
</block>
<block>
<key>STS_generator_withoutCP</key>
<param><key>id</key><value>STS_generator_withoutCP_0</value></param>
</block>
<block>
<key>basic_qpskofdm_tx_withoutCP</key>
<param><key>id</key><value>basic_qpskofdm_tx_withoutCP_0</value></param>
<param><key>N</key><value>1</value></param>
<param><key>NFFT</key><value>TxParams.NFFT</value></param>
<param><key>syms_filename</key><value>/tmp/qpsk_syms.bin</value></param>
<param><key>used_sc</key><value>TxParams.UsedSC</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/tmp/sts_gmp_input.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>M</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/tmp/sts_input.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>file</key><value>/tmp/ofdm_input.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2</value></param>
<param><key>file</key><value>/tmp/ofdm_gmp_input.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>M</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>TxParams.BBampl</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>TxParams.BBampl</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>TxParams.SampRate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_0</value></param>
<param><key>cp_len</key><value>TxParams.CPlen</value></param>
<param><key>input_size</key><value>TxParams.NFFT</value></param>
<param><key>tagname</key><value></value></param>
<param><key>rolloff</key><value>32</value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_0_0</value></param>
<param><key>cp_len</key><value>TxParams.CPlen</value></param>
<param><key>input_size</key><value>TxParams.NFFT</value></param>
<param><key>tagname</key><value></value></param>
<param><key>rolloff</key><value>32</value></param>
</block>
<block>
<key>dpd_stream_to_gmp_vector</key>
<param><key>id</key><value>dpd_stream_to_gmp_vector_0_0</value></param>
<param><key>dpd_params</key><value>(DPDParams.Ka,DPDParams.La,DPDParams.Kb,DPDParams.Mb,DPDParams.Lb)</value></param>
</block>
<block>
<key>dpd_stream_to_gmp_vector</key>
<param><key>id</key><value>dpd_stream_to_gmp_vector_0_0_0</value></param>
<param><key>dpd_params</key><value>(DPDParams.Ka,DPDParams.La,DPDParams.Kb,DPDParams.Mb,DPDParams.Lb)</value></param>
</block>
<block>
<key>dpd_upsample</key>
<param><key>id</key><value>dpd_upsample_0</value></param>
<param><key>ovx</key><value>TxParams.Ovx</value></param>
</block>
<block>
<key>dpd_upsample</key>
<param><key>id</key><value>dpd_upsample_0_0</value></param>
<param><key>ovx</key><value>TxParams.Ovx</value></param>
</block>
<block>
<key>eightX_elliptic_filter</key>
<param><key>id</key><value>eightX_elliptic_filter_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>eightX_elliptic_filter</key>
<param><key>id</key><value>eightX_elliptic_filter_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>sixX_elliptic_filter</key>
<param><key>id</key><value>sixX_elliptic_filter_0</value></param>
</block>
<block>
<key>sixX_elliptic_filter</key>
<param><key>id</key><value>sixX_elliptic_filter_0_0</value></param>
</block>
<connection><source_block_id>STS_generator_withoutCP_0</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>basic_qpskofdm_tx_withoutCP_0</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>dpd_upsample_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>dpd_upsample_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>dpd_stream_to_gmp_vector_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_stream_to_gmp_vector_0_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_stream_to_gmp_vector_0_0_0</source_block_id><sink_block_id>blocks_file_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_upsample_0</source_block_id><sink_block_id>eightX_elliptic_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_upsample_0</source_block_id><sink_block_id>sixX_elliptic_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_upsample_0_0</source_block_id><sink_block_id>eightX_elliptic_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_upsample_0_0</source_block_id><sink_block_id>sixX_elliptic_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>eightX_elliptic_filter_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>eightX_elliptic_filter_0</source_block_id><sink_block_id>dpd_stream_to_gmp_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>eightX_elliptic_filter_1</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>eightX_elliptic_filter_1</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sixX_elliptic_filter_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sixX_elliptic_filter_0</source_block_id><sink_block_id>dpd_stream_to_gmp_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sixX_elliptic_filter_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sixX_elliptic_filter_0_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
