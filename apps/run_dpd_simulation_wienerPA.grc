<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>DPDParams</value></param>
<param><key>field0</key><value>Ka</value></param>
<param><key>field1</key><value>La</value></param>
<param><key>field2</key><value>Kb</value></param>
<param><key>field3</key><value>Mb</value></param>
<param><key>field4</key><value>Lb</value></param>
<param><key>value0</key><value>5</value></param>
<param><key>value2</key><value>5</value></param>
<param><key>value1</key><value>3</value></param>
<param><key>value4</key><value>3</value></param>
<param><key>value3</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>DPDParams.Ka*DPDParams.La+DPDParams.Kb*DPDParams.Mb*DPDParams.Lb</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>STSParams</value></param>
<param><key>value2</key><value>128</value></param>
<param><key>field0</key><value>Len</value></param>
<param><key>field1</key><value>SAdiff</value></param>
<param><key>field2</key><value>CorrLen</value></param>
<param><key>field3</key><value>PeakVal</value></param>
<param><key>value0</key><value>512</value></param>
<param><key>value3</key><value>55</value></param>
<param><key>value1</key><value>[-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,-1,1,1,1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,1,1,-1,-1,-1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,-1,1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,1,1,1,-1,-1,-1,-1,1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,-1,-1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,-1,-1,1,1,1,1,1,-1,-1,-1,-1,-1,1,1,1,1]</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>TxParams</value></param>
<param><key>value2</key><value>512</value></param>
<param><key>field0</key><value>NFFT</value></param>
<param><key>field1</key><value>UsedSC</value></param>
<param><key>field2</key><value>CPlen</value></param>
<param><key>field3</key><value>Ovx</value></param>
<param><key>field4</key><value>SampRate</value></param>
<param><key>field5</key><value>N</value></param>
<param><key>value5</key><value>4000</value></param>
<param><key>value0</key><value>2048</value></param>
<param><key>value3</key><value>6</value></param>
<param><key>value4</key><value>100e6/50.0</value></param>
<param><key>value1</key><value>1680</value></param>
</block>
<block>
<key>STS_generator_withoutCP</key>
<param><key>id</key><value>STS_generator_withoutCP_0</value></param>
</block>
<block>
<key>basic_qpskofdm_tx_withoutCP</key>
<param><key>id</key><value>basic_qpskofdm_tx_withoutCP_0</value></param>
<param><key>N</key><value>1</value></param>
<param><key>NFFT</key><value>TxParams.NFFT</value></param>
<param><key>syms_filename</key><value>/tmp/qpsk_syms.bin</value></param>
<param><key>used_sc</key><value>TxParams.UsedSC</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/radio1/Documents/gr-dpd/examples/ofdm_wPA_input.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/home/radio1/Documents/gr-dpd/examples/ofdm_wPA_output.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_2</value></param>
<param><key>file</key><value>/home/radio1/Documents/gr-dpd/examples/ofdm_dpd_input.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_2_0</value></param>
<param><key>file</key><value>/home/radio1/Documents/gr-dpd/examples/ofdm_dpd_output.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>12</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>0.002</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>interp</key><value>TxParams.N</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>TxParams.NFFT</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>num_items</key><value>(TxParams.NFFT+TxParams.CPlen)*TxParams.Ovx*5</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0_0</value></param>
<param><key>num_items</key><value>(TxParams.NFFT+TxParams.CPlen)*TxParams.Ovx*5</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0_0_0</value></param>
<param><key>num_items</key><value>(TxParams.NFFT+TxParams.CPlen)*TxParams.Ovx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0</value></param>
<param><key>lengths</key><value>5, 1, TxParams.N</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>(TxParams.NFFT+TxParams.CPlen)</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"ofdm_block_len"</value></param>
<param><key>packet_len</key><value>(TxParams.NFFT+TxParams.CPlen)*TxParams.Ovx</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>M</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_0_1</value></param>
<param><key>len_tag_key</key><value>"ofdm_block_len"</value></param>
<param><key>packet_len</key><value>(TxParams.NFFT+TxParams.CPlen)*TxParams.Ovx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_0_1_0</value></param>
<param><key>len_tag_key</key><value>"ofdm_block_len"</value></param>
<param><key>packet_len</key><value>(TxParams.NFFT+TxParams.CPlen)*TxParams.Ovx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>TxParams.NFFT+TxParams.CPlen</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>TxParams.NFFT+TxParams.CPlen</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>TxParams.SampRate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>(TxParams.NFFT+TxParams.CPlen)</value></param>
<param><key>vector</key><value>[0]*(TxParams.NFFT+TxParams.CPlen)*TxParams.Ovx*5</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>(TxParams.NFFT+TxParams.CPlen)</value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_0</value></param>
<param><key>cp_len</key><value>TxParams.CPlen</value></param>
<param><key>input_size</key><value>TxParams.NFFT</value></param>
<param><key>tagname</key><value></value></param>
<param><key>rolloff</key><value>32</value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_0_0</value></param>
<param><key>cp_len</key><value>TxParams.CPlen</value></param>
<param><key>input_size</key><value>TxParams.NFFT</value></param>
<param><key>tagname</key><value></value></param>
<param><key>rolloff</key><value>32</value></param>
</block>
<block>
<key>dpd_gain_phase_calibrate</key>
<param><key>id</key><value>dpd_gain_phase_calibrate_0</value></param>
<param><key>ref_len</key><value>(TxParams.NFFT+TxParams.CPlen)*TxParams.Ovx</value></param>
</block>
<block>
<key>dpd_pa_wiener_model</key>
<param><key>id</key><value>dpd_pa_wiener_model_0</value></param>
</block>
<block>
<key>dpd_polynomial_regressor_vector</key>
<param><key>id</key><value>dpd_polynomial_regressor_vector_0</value></param>
<param><key>dpd_params</key><value>(DPDParams.Ka,DPDParams.La,DPDParams.Kb,DPDParams.Mb,DPDParams.Lb)</value></param>
</block>
<block>
<key>dpd_postdistorter</key>
<param><key>id</key><value>dpd_postdistorter_0</value></param>
<param><key>dpd_params</key><value>(DPDParams.Ka,DPDParams.La,DPDParams.Kb,DPDParams.Mb,DPDParams.Lb)</value></param>
</block>
<block>
<key>dpd_predistorter</key>
<param><key>id</key><value>dpd_predistorter_0</value></param>
<param><key>cp_len</key><value>TxParams.CPlen</value></param>
<param><key>dpd_params</key><value>(DPDParams.Ka,DPDParams.La,DPDParams.Kb,DPDParams.Mb,DPDParams.Lb)</value></param>
<param><key>NFFT</key><value>TxParams.NFFT</value></param>
<param><key>num_zero_syms</key><value>5</value></param>
<param><key>ovx</key><value>TxParams.Ovx</value></param>
</block>
<block>
<key>dpd_stream_to_message</key>
<param><key>id</key><value>dpd_stream_to_message_0</value></param>
<param><key>msg_len</key><value>(TxParams.NFFT+TxParams.CPlen)*TxParams.Ovx</value></param>
</block>
<block>
<key>dpd_upsample</key>
<param><key>id</key><value>dpd_upsample_0</value></param>
<param><key>ovx</key><value>TxParams.Ovx</value></param>
</block>
<block>
<key>hier_dpd_elliptic_filter</key>
<param><key>id</key><value>hier_dpd_elliptic_filter_0</value></param>
</block>
<block>
<key>logpwrfft_x</key>
<param><key>id</key><value>logpwrfft_x_0</value></param>
<param><key>avg_alpha</key><value>1.0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>8192</value></param>
<param><key>frame_rate</key><value>30</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ref_scale</key><value>2</value></param>
<param><key>sample_rate</key><value>TxParams.SampRate</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>TxParams.SampRate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>8192</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-30</value></param>
<param><key>ymin</key><value>-100</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>TxParams.SampRate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>8192</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>qtgui_tab_widget_0</value></param>
<param><key>label0</key><value>Tab 0</value></param>
<param><key>label1</key><value>Tab 1</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>8192</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0</value></param>
</block>
<connection><source_block_id>STS_generator_withoutCP_0</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>basic_qpskofdm_tx_withoutCP_0</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>logpwrfft_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_0</source_block_id><sink_block_id>dpd_stream_to_message_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_0_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>dpd_predistorter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0_1</source_block_id><sink_block_id>dpd_gain_phase_calibrate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0_1_0</source_block_id><sink_block_id>dpd_postdistorter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>dpd_upsample_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_gain_phase_calibrate_0</source_block_id><sink_block_id>blocks_skiphead_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_pa_wiener_model_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_polynomial_regressor_vector_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_postdistorter_0</source_block_id><sink_block_id>blocks_file_sink_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_postdistorter_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_postdistorter_0</source_block_id><sink_block_id>dpd_predistorter_0</sink_block_id><source_key>taps</source_key><sink_key>taps</sink_key></connection>
<connection><source_block_id>dpd_predistorter_0</source_block_id><sink_block_id>dpd_postdistorter_0</sink_block_id><source_key>PA_input</source_key><sink_key>PA_input</sink_key></connection>
<connection><source_block_id>dpd_predistorter_0</source_block_id><sink_block_id>blocks_file_sink_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_predistorter_0</source_block_id><sink_block_id>dpd_pa_wiener_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_stream_to_message_0</source_block_id><sink_block_id>dpd_gain_phase_calibrate_0</sink_block_id><source_key>samples</source_key><sink_key>samples</sink_key></connection>
<connection><source_block_id>dpd_upsample_0</source_block_id><sink_block_id>hier_dpd_elliptic_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_dpd_elliptic_filter_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_dpd_elliptic_filter_0</source_block_id><sink_block_id>blocks_skiphead_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_dpd_elliptic_filter_0</source_block_id><sink_block_id>dpd_polynomial_regressor_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_dpd_elliptic_filter_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
