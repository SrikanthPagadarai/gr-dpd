<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>DPDParams</value></param>
<param><key>field0</key><value>Ka</value></param>
<param><key>field1</key><value>La</value></param>
<param><key>field2</key><value>Kb</value></param>
<param><key>field3</key><value>Mb</value></param>
<param><key>field4</key><value>Lb</value></param>
<param><key>value0</key><value>5</value></param>
<param><key>value2</key><value>5</value></param>
<param><key>value1</key><value>2</value></param>
<param><key>value4</key><value>5</value></param>
<param><key>value3</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>DPDParams.Ka*DPDParams.La+DPDParams.Kb*DPDParams.Mb*DPDParams.Lb</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>TxParams</value></param>
<param><key>value7</key><value>25</value></param>
<param><key>value2</key><value>512</value></param>
<param><key>value6</key><value>500e6</value></param>
<param><key>field0</key><value>NFFT</value></param>
<param><key>field1</key><value>UsedSC</value></param>
<param><key>field2</key><value>CPlen</value></param>
<param><key>field3</key><value>Ovx</value></param>
<param><key>field4</key><value>SampRate</value></param>
<param><key>field5</key><value>N</value></param>
<param><key>field6</key><value>CenterFreq</value></param>
<param><key>field7</key><value>BBampl</value></param>
<param><key>value5</key><value>2000</value></param>
<param><key>value0</key><value>2048</value></param>
<param><key>value3</key><value>6</value></param>
<param><key>value4</key><value>100e6/128.0</value></param>
<param><key>value1</key><value>1680</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>predistorter_taps</value></param>
<param><key>value</key><value>[0.362106368189909 + 0.0776532301901294j,-0.0488637227081121 - 0.0571086421269023j,0.00322462436421709 + 0.0415675764426229j,-0.0204469377883343 + 0.0290391635581614j,0.0434108482431908 - 0.0171862985867146j,0.0280300591899845 + 0.0201796403223347j,-0.0212935493164440 + 0.0465551529337543j,0.0235109801162112 - 0.000962837079500394j,0.0140959727257688 + 0.00613303377274443j,-0.00745559633232974 + 0.0135463896745103j,0.00117868076158223 + 0.00365541603073222j,-0.000816697116867547 + 0.00269578012390487j,-0.00157491073550183 + 0.00262751684865002j,-0.000296386690841875 + 0.00106904647681836j,-0.000596393951317224 + 0.000683628662703438j,0.0479193052958208 - 0.00148715555011485j,-0.100792743606575 + 0.0309335204769590j,0.00856963958364975 - 0.0886958622394982j,-0.000762110640914655 + 0.0135583672958376j,-0.0116976494478828 + 0.00841201876525232j,-0.0111777753105057 + 0.0127239280821155j,-0.000975131303738841 + 0.00568865089945838j,-0.00279774756494357 + 0.00299450946728443j,-0.00350818008196610 + 0.00457744870990756j,-0.000437241164809019 + 0.00129865382631312j,-0.000712959599968064 + 0.000718417353862644j,-0.000766942654607915 + 0.000920360565520600j,-0.000104167340041671 + 0.000229731359334165j,-0.000139936660093248 + 0.000132999949085364j,-0.000134276634050811 + 0.000153063373198754j,0.0204893870106899 - 0.110422923677045j,-0.0252352449605620 + 0.0230588532792984j,-0.000858682229500893 - 0.131511266541595j,-0.00527937640126321 - 0.0119693795490590j,-0.0204831776046533 - 0.00166768139490700j,-0.0131893581446491 + 0.00621599900082954j,-0.00152523275399617 + 0.000649080626278678j,-0.00425233237177143 + 0.00148620573265324j,-0.00288892027298556 + 0.00528904183305664j,-0.000493737720878397 + 0.000449212328974311j,-0.000812802895630406 + 0.000501535949235668j,-0.000481261336581358 + 0.00116423176035601j,-0.000107385269187522 + 0.000100333884261851j,-0.000135488564020465 + 0.000101346933332143j,-6.91831863207785e-05 + 0.000193939454071141j,0.0475549497695017 + 0.0594398904323432j,0.0134732760545452 + 0.115089028686551j,-0.000824417466026341 + 0.0406414638819978j,-0.0123320219405038 - 0.0273994075558307j,0.000668051317025560 - 0.0174014345142248j,-0.00584441458432949 + 0.00958301646937615j,-0.00279406323499037 - 0.00309695762987658j,-0.000853762121510541 - 0.000785545853325465j,-0.00195053741204463 + 0.00508142122375241j,-0.000600194070596117 - 0.000107183710789326j,-0.000273809485603645 + 0.000284437308680371j,-0.000355113383592788 + 0.00115601791336205j,-0.000106768791709071 + 2.57210985935649e-05j,-5.14137328622852e-05 + 8.23029732247567e-05j,-4.99905917056779e-05 + 0.000197319596065133j]</value></param>
</block>
<block>
<key>basic_qpskofdm_tx_withoutCP</key>
<param><key>id</key><value>basic_qpskofdm_tx_withoutCP_0</value></param>
<param><key>N</key><value>TxParams.N</value></param>
<param><key>NFFT</key><value>TxParams.NFFT</value></param>
<param><key>syms_filename</key><value>/tmp/qpsk_syms.bin</value></param>
<param><key>used_sc</key><value>TxParams.UsedSC</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_1</value></param>
<param><key>file</key><value>/tmp/predistorted_ofdm_input.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>TxParams.BBampl</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>TxParams.SampRate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_0</value></param>
<param><key>cp_len</key><value>TxParams.CPlen</value></param>
<param><key>input_size</key><value>TxParams.NFFT</value></param>
<param><key>tagname</key><value></value></param>
<param><key>rolloff</key><value>32</value></param>
</block>
<block>
<key>dpd_stream_to_gmp_vector</key>
<param><key>id</key><value>dpd_stream_to_gmp_vector_0</value></param>
<param><key>dpd_params</key><value>(DPDParams.Ka,DPDParams.La,DPDParams.Kb,DPDParams.Mb,DPDParams.Lb)</value></param>
</block>
<block>
<key>dpd_upsample</key>
<param><key>id</key><value>dpd_upsample_0</value></param>
<param><key>ovx</key><value>TxParams.Ovx</value></param>
</block>
<block>
<key>dpd_vector_vector_multiply</key>
<param><key>id</key><value>dpd_vector_vector_multiply_0</value></param>
<param><key>const_vec</key><value>predistorter_taps</value></param>
<param><key>vec_len</key><value>M</value></param>
</block>
<block>
<key>sixX_elliptic_filter</key>
<param><key>id</key><value>sixX_elliptic_filter_0</value></param>
</block>
<connection><source_block_id>basic_qpskofdm_tx_withoutCP_0</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>dpd_upsample_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_stream_to_gmp_vector_0</source_block_id><sink_block_id>dpd_vector_vector_multiply_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_upsample_0</source_block_id><sink_block_id>sixX_elliptic_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_vector_vector_multiply_0</source_block_id><sink_block_id>blocks_file_sink_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sixX_elliptic_filter_0</source_block_id><sink_block_id>dpd_stream_to_gmp_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
