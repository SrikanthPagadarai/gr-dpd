<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>DPDParams</value></param>
<param><key>field0</key><value>Ka</value></param>
<param><key>field1</key><value>La</value></param>
<param><key>field2</key><value>Kb</value></param>
<param><key>field3</key><value>Mb</value></param>
<param><key>field4</key><value>Lb</value></param>
<param><key>value0</key><value>5</value></param>
<param><key>value2</key><value>5</value></param>
<param><key>value1</key><value>2</value></param>
<param><key>value4</key><value>5</value></param>
<param><key>value3</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>DPDParams.Ka*DPDParams.La+DPDParams.Kb*DPDParams.Mb*DPDParams.Lb</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>TxParams</value></param>
<param><key>value7</key><value>25</value></param>
<param><key>value2</key><value>512</value></param>
<param><key>value6</key><value>500e6</value></param>
<param><key>field0</key><value>NFFT</value></param>
<param><key>field1</key><value>UsedSC</value></param>
<param><key>field2</key><value>CPlen</value></param>
<param><key>field3</key><value>Ovx</value></param>
<param><key>field4</key><value>SampRate</value></param>
<param><key>field5</key><value>N</value></param>
<param><key>field6</key><value>CenterFreq</value></param>
<param><key>field7</key><value>BBampl</value></param>
<param><key>value5</key><value>2000</value></param>
<param><key>value0</key><value>2048</value></param>
<param><key>value3</key><value>6</value></param>
<param><key>value4</key><value>100e6/128.0</value></param>
<param><key>value1</key><value>1680</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>predistorter_taps</value></param>
<param><key>value</key><value>[0.671750203018903 - 0.0443801555842965j,0.157131543142509 - 0.0277493595085261j,-1.42548853349160 - 0.301169148622463j,-1.12259467213133 - 0.467217458625795j,6.84991875700703 + 1.29458360257855j,0.763638899467437 - 1.76991841993743j,6.31588193921699 + 1.14683043612068j,0.764688584601540 - 0.940332655573814j,3.41775808779199 + 0.615212196616559j,0.350149777990235 - 0.367077298645826j,0.371651732798366 + 0.362549320526227j,0.984636156464816 + 0.627583280883196j,0.573895382290049 + 0.428895623904638j,-0.596954580285319 - 0.153964397590787j,-0.280841570679598 + 0.387333728118071j,1.45755258394735 + 1.29140857870930j,-0.0227250705985510 - 0.219244757124874j,0.212436697547024 - 0.168833739137731j,0.253523561528902 + 0.0759008992867574j,1.13924932538197 + 0.524675365700852j,1.42947777054145 + 0.530436245117277j,-1.25024501024546 - 0.348210211755300j,-1.46498514646987 + 0.0521714981349570j,-0.822499458041295 + 0.396863686809165j,-0.0129364767311810 + 0.433482299195506j,0.704229561996537 + 0.160059105744003j,-1.01875912451049 - 0.180452512170588j,-1.15723798629625 + 0.122842214690718j,-0.616400734377395 + 0.308059216130466j,-0.117701519301856 + 0.240025291290802j,0.268197291337779 + 0.0414961068206065j,-0.555333007739212 - 0.0696705580222054j,-0.604609017030430 + 0.0880496172287855j,-0.303753391268539 + 0.163597627750474j,-0.0608365064502513 + 0.109167961153114j,-0.111724125728109 - 0.231135879890563j,-0.0801493903146885 - 0.225388498474521j,0.536957615780508 - 0.183025885031883j,0.489844285871507 + 0.0255568114221156j,-0.0813981389832762 - 0.261608743993894j,-0.337990751511593 + 0.596284143058538j,-0.531942077962333 - 0.411618004630021j,-0.639412881226935 - 0.465533653960218j,-0.615107971084565 - 0.240163805393965j,0.117668998051658 - 0.768867066626753j,-1.11339076420959 - 0.0657143996348948j,-1.83315146972896 - 0.278568396169488j,-1.39553635990968 - 0.00572866257627034j,-0.842250831033848 + 0.0451284417356274j,-0.362522534529461 - 0.276926383562189j,-0.875988212309135 - 0.144291664988313j,-1.29422769782851 - 0.0895332625259586j,-0.865045317146037 + 0.109330366846701j,-0.420830906537965 + 0.0884001682492232j,-0.194423554560666 - 0.0621072444498809j,-0.477681719625712 - 0.0842840361693052j,-0.648402357749432 - 0.0145888393627265j,-0.396789616948244 + 0.0808977109721323j,-0.162312085320825 + 0.0555242645211244j,-0.0723321431156961 - 0.00449709194734063j]</value></param>
</block>
<block>
<key>basic_qpskofdm_tx_withoutCP</key>
<param><key>id</key><value>basic_qpskofdm_tx_withoutCP_0</value></param>
<param><key>N</key><value>TxParams.N</value></param>
<param><key>NFFT</key><value>TxParams.NFFT</value></param>
<param><key>syms_filename</key><value>/tmp/qpsk_syms.bin</value></param>
<param><key>used_sc</key><value>TxParams.UsedSC</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_1</value></param>
<param><key>file</key><value>/tmp/predistorted_ofdm_input.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>TxParams.BBampl</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>TxParams.SampRate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_0</value></param>
<param><key>cp_len</key><value>TxParams.CPlen</value></param>
<param><key>input_size</key><value>TxParams.NFFT</value></param>
<param><key>tagname</key><value></value></param>
<param><key>rolloff</key><value>32</value></param>
</block>
<block>
<key>dpd_stream_to_gmp_vector</key>
<param><key>id</key><value>dpd_stream_to_gmp_vector_0</value></param>
<param><key>dpd_params</key><value>(DPDParams.Ka,DPDParams.La,DPDParams.Kb,DPDParams.Mb,DPDParams.Lb)</value></param>
</block>
<block>
<key>dpd_upsample</key>
<param><key>id</key><value>dpd_upsample_0</value></param>
<param><key>ovx</key><value>TxParams.Ovx</value></param>
</block>
<block>
<key>dpd_vector_vector_multiply</key>
<param><key>id</key><value>dpd_vector_vector_multiply_0</value></param>
<param><key>const_vec</key><value>predistorter_taps</value></param>
<param><key>vec_len</key><value>M</value></param>
</block>
<block>
<key>gr_dpd_elliptic_filter</key>
<param><key>id</key><value>gr_dpd_elliptic_filter_0</value></param>
</block>
<connection><source_block_id>basic_qpskofdm_tx_withoutCP_0</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>dpd_upsample_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_stream_to_gmp_vector_0</source_block_id><sink_block_id>dpd_vector_vector_multiply_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_upsample_0</source_block_id><sink_block_id>gr_dpd_elliptic_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_vector_vector_multiply_0</source_block_id><sink_block_id>blocks_file_sink_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_dpd_elliptic_filter_0</source_block_id><sink_block_id>dpd_stream_to_gmp_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
