<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>DPDParams</value></param>
<param><key>field0</key><value>Ka</value></param>
<param><key>field1</key><value>La</value></param>
<param><key>field2</key><value>Kb</value></param>
<param><key>field3</key><value>Mb</value></param>
<param><key>field4</key><value>Lb</value></param>
<param><key>value0</key><value>5</value></param>
<param><key>value2</key><value>5</value></param>
<param><key>value1</key><value>3</value></param>
<param><key>value4</key><value>3</value></param>
<param><key>value3</key><value>3</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>DPDParams_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>field0</key><value>Ka</value></param>
<param><key>field1</key><value>La</value></param>
<param><key>field2</key><value>Kb</value></param>
<param><key>field3</key><value>Mb</value></param>
<param><key>field4</key><value>Lb</value></param>
<param><key>value0</key><value>6</value></param>
<param><key>value2</key><value>3</value></param>
<param><key>value1</key><value>7</value></param>
<param><key>value4</key><value>3</value></param>
<param><key>value3</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>DPDParams.Ka*DPDParams.La+DPDParams.Kb*DPDParams.Mb*DPDParams.Lb</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>STS_len</value></param>
<param><key>value</key><value>TxParams.NFFT/4 </value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>TxParams</value></param>
<param><key>value2</key><value>512</value></param>
<param><key>value6</key><value>0.5e9</value></param>
<param><key>field0</key><value>NFFT</value></param>
<param><key>field1</key><value>UsedSC</value></param>
<param><key>field2</key><value>CPlen</value></param>
<param><key>field3</key><value>Ovx</value></param>
<param><key>field4</key><value>SampRate</value></param>
<param><key>field5</key><value>N</value></param>
<param><key>field6</key><value>CenterFreq</value></param>
<param><key>value5</key><value>50000</value></param>
<param><key>value0</key><value>2048</value></param>
<param><key>value3</key><value>6</value></param>
<param><key>value4</key><value>100e6/100.0</value></param>
<param><key>value1</key><value>1680</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>corr_len</value></param>
<param><key>value</key><value>STS_len</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>peak_val</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>stsAmplDiff</value></param>
<param><key>value</key><value>[1,1,1,-1,-1,-1,-1,-1,1,1,1,1,1,-1,-1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,-1,-1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,1,-1,-1,-1,-1,1,1,1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,1,-1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,1,1,-1,-1,-1,1,1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,1,1,1,-1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1]</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/tmp/ofdm_PA_out.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/tmp/ofdm_PA_in.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/tmp/sts_gmp_input.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>M</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>file</key><value>/tmp/ofdm_gmp_input.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>M</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_1</value></param>
<param><key>file</key><value>/tmp/ofdm_input_working.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_2</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>4096</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>(TxParams.NFFT+TxParams.CPlen)+(TxParams.NFFT+TxParams.CPlen)*TxParams.Ovx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0_0</value></param>
<param><key>num_items</key><value>(TxParams.NFFT+TxParams.CPlen)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0_0_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>num_items</key><value>(TxParams.NFFT+TxParams.CPlen)*TxParams.Ovx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0_0</value></param>
<param><key>lengths</key><value>(TxParams.NFFT+TxParams.CPlen)*TxParams.Ovx*5, (TxParams.NFFT+TxParams.CPlen)*TxParams.Ovx, (TxParams.NFFT+TxParams.CPlen)*TxParams.Ovx*TxParams.N</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>M</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"ofdm_block_len"</value></param>
<param><key>packet_len</key><value>(TxParams.NFFT+TxParams.CPlen)*TxParams.Ovx</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>M</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_0_1</value></param>
<param><key>len_tag_key</key><value>"ofdm_block_len"</value></param>
<param><key>packet_len</key><value>(TxParams.NFFT+TxParams.CPlen)*TxParams.Ovx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_0_1_0</value></param>
<param><key>len_tag_key</key><value>"ofdm_block_len"</value></param>
<param><key>packet_len</key><value>(TxParams.NFFT+TxParams.CPlen)*TxParams.Ovx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>M</value></param>
</block>
<block>
<key>dpd_Agilent_N1996A</key>
<param><key>id</key><value>dpd_Agilent_N1996A_0</value></param>
<param><key>frequency</key><value>TxParams.CenterFreq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>ip_addr</key><value>169.254.251.20</value></param>
<param><key>nb_points</key><value>4096</value></param>
<param><key>resbw</key><value>5e2</value></param>
<param><key>span</key><value>TxParams.SampRate</value></param>
</block>
<block>
<key>dpd_gain_phase_calibrate</key>
<param><key>id</key><value>dpd_gain_phase_calibrate_0</value></param>
<param><key>ref_len</key><value>(TxParams.NFFT+TxParams.CPlen)*TxParams.Ovx</value></param>
</block>
<block>
<key>dpd_postdistorter</key>
<param><key>id</key><value>dpd_postdistorter_0</value></param>
<param><key>dpd_params</key><value>(DPDParams.Ka,DPDParams.La,DPDParams.Kb,DPDParams.Mb,DPDParams.Lb)</value></param>
<param><key>iter_limit</key><value>1000</value></param>
<param><key>save_log</key><value>0</value></param>
</block>
<block>
<key>dpd_predistorter_training</key>
<param><key>id</key><value>dpd_predistorter_training_0</value></param>
<param><key>cp_len</key><value>TxParams.CPlen</value></param>
<param><key>M</key><value>M</value></param>
<param><key>NFFT</key><value>TxParams.NFFT</value></param>
<param><key>num_zero_syms</key><value>5</value></param>
<param><key>ovx</key><value>TxParams.Ovx</value></param>
<param><key>save_log</key><value>0</value></param>
</block>
<block>
<key>dpd_stream_to_message</key>
<param><key>id</key><value>dpd_stream_to_message_0</value></param>
<param><key>msg_len</key><value>(TxParams.NFFT+TxParams.CPlen)*TxParams.Ovx</value></param>
</block>
<block>
<key>dpd_sts_blocker</key>
<param><key>id</key><value>dpd_sts_blocker_0</value></param>
</block>
<block>
<key>estimate_integer_delay</key>
<param><key>id</key><value>estimate_integer_delay_0</value></param>
<param><key>corr_len</key><value>corr_len</value></param>
<param><key>peak_val</key><value>peak_val</value></param>
<param><key>STS_signed_ampl_diff</key><value>stsAmplDiff</value></param>
<param><key>STS_len</key><value>STS_len</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>uhd.tune_request(TxParams.CenterFreq, rf_freq=(TxParams.CenterFreq+lo_offset),rf_freq_policy=uhd.tune_request.POLICY_MANUAL)</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr=192.168.10.2"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>TxParams.SampRate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>False</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>TxParams.CenterFreq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr=192.168.10.2"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>TxParams.SampRate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_1</source_block_id><sink_block_id>dpd_stream_to_message_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_0_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>dpd_predistorter_training_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0_1</source_block_id><sink_block_id>dpd_gain_phase_calibrate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0_1_0</source_block_id><sink_block_id>dpd_postdistorter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_Agilent_N1996A_0</source_block_id><sink_block_id>blocks_null_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_gain_phase_calibrate_0</source_block_id><sink_block_id>blocks_file_sink_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_gain_phase_calibrate_0</source_block_id><sink_block_id>blocks_skiphead_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_postdistorter_0</source_block_id><sink_block_id>dpd_predistorter_training_0</sink_block_id><source_key>taps</source_key><sink_key>taps</sink_key></connection>
<connection><source_block_id>dpd_predistorter_training_0</source_block_id><sink_block_id>dpd_postdistorter_0</sink_block_id><source_key>PA_input</source_key><sink_key>PA_input</sink_key></connection>
<connection><source_block_id>dpd_predistorter_training_0</source_block_id><sink_block_id>blocks_file_sink_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_predistorter_training_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_stream_to_message_0</source_block_id><sink_block_id>dpd_gain_phase_calibrate_0</sink_block_id><source_key>samples</source_key><sink_key>samples</sink_key></connection>
<connection><source_block_id>dpd_sts_blocker_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dpd_sts_blocker_0</source_block_id><sink_block_id>blocks_skiphead_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>estimate_integer_delay_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>estimate_integer_delay_0</source_block_id><sink_block_id>dpd_sts_blocker_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>estimate_integer_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
